IMAGE_INSTALL_append = " \
    linux-firmware-rtl8192cu \
    linux-firmware-ralink \
    "

